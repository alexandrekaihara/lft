options:
  parameters:
    generate_options: no_gui
    id: single_ue
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2000
    alias: ue
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2100
    alias: enb
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2101
    alias: enb
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2001
    alias: ue
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_req_source_0, '0', zeromq_rep_sink_0, '0']
- [zeromq_req_source_0_0, '0', zeromq_rep_sink_0_0, '0']

metadata:
  file_format: 1
